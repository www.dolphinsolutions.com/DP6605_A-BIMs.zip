Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-02-20T21:57:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 20 21:57:18 2023 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\965cbf6d-762b-4767-b912-ee18d69de2f7\b2329b2c-c005-47e9-b2d8-57b750e22136\ifc * Database version: 5507 * Database creation date: Mon Feb 20 21:57:17 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 20 21:57:17 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 20 21:57:17 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowController: DB3100, DB3100:DB3100:496062
In: Level 1
Type - PredefinedType: MIXING; Material: Default
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_78:Shower manual water supply sets; CodePerformance: WRAS_TMV2; Color: Various; Constituents: n/a; Description: ShowerValveAndTwoWayDiverter; DurationUnit: year; ExpectedLife: n/a; Features: DB3100_Lever_DB3101_Leverless; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel_.5/PowderCoated_.6/CeramicCoated; Grade: Various_316SS; IfcExportAs: IfcValveType; IfcExportType: MIXING; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Valve/Brass_FacePlate/StainlessSteel; ModelNumber: DB3100/DB3101; ModelReference: DolphinSolutionsLimited_ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter; Name: ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter_DB3100_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 215 mm; NominalLength: 45 mm; NominalWidth: 130 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-shower-valve/; ReplacementCost: n/a; Shape: Rectangular; Size: 130x215x45; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3100; Uniclass2015Code: Pr_40_20_87_78; Uniclass2015Title: Shower manual water supply sets; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 5; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Materials and Finishes - Primary Material: Default; Secondary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: DB3100
Type - Pset_ValveTypeFaucet - Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel_.5/PowderCoated_.6/CeramicCoated
Pset_DistributionFlowElementCommon - Reference: DB3100:DB3100; sets with these values: 2
Pset_ElementShading - Color: Various
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter_DB3100_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Elevation from Level: 750 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 750 mm
Dimensions - Area: 0.0423619 m2; Volume: 0.000242714 m3
Identity Data - Mark: 376
Other - Family: DB3100: DB3100; Family and Type: DB3100: DB3100; Type: DB3100: DB3100; Type Id: DB3100: DB3100
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: BC5083-101:Standard, BC5083-101:Standard:496078
In: Level 1
Other(Type) - Category: Plumbing Fixtures; Family Name: BC5083-101
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_25_71_53_06:Bathroom mirrors; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Wall-mounted mirror; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Form: Wall-mounted; Grade: n/a; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Glass; ModelNumber: BC5083-101; ModelReference: DolphinSolutionsLimited_Mirror; Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; NBSDescription: Bathroom mirrors; NBSReference: 45-35-72/336; NBSTypeID: n/a; NominalHeight: 1000; NominalLength: 15; NominalWidth: 400; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.95.17.17; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 400 x 1000 x 15 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_25_71_53_06; Uniclass2015Title: Bathroom mirrors; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Dimensions(Type) - Depth: 10 mm; Height: 1000 mm; Width: 400 mm
Constraints(Type) - Default Elevation: 0 mm
Pset_DistributionFlowElementCommon - Reference: BC5083-101:Standard; sets with these values: 2
Pset_ElementShading - Color: n/a
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Mirror; Manufacturer: mailto:info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 600 mm; Host: Level : Level 1; Offset from Host: 600 mm
Dimensions - Area: 0.827875 m2; Volume: 0.004 m3
Identity Data - Mark: 392
Other - Category: Plumbing Fixtures; Family: BC5083-101: Standard; Family and Type: BC5083-101: Standard; Type: BC5083-101: Standard; Type Id: BC5083-101: Standard
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: BC5083-121:Standard, BC5083-121:Standard:496077
In: Level 1
Other(Type) - Category: Plumbing Fixtures; Family Name: BC5083-121
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits; CodePerformance: BS8300:DocM; Color: Brushed Satin; Constituents: n/a; Description: Ceiling fitted assistance call pull cord unit with wall mounted reset; DurationUnit: year; ExpectedLife: n/a; Features: BS8300:DocM_PullCord_OpenDoorIndicator_ResetButton; Finish: Brushed Satin; Form: Surface-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-121; ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit; Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; NBSDescription: AssistanceCallPulCordUnits; NBSReference: 90-70-05/320; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 0; NominalWidth: 0; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.85.30.24.11; Operation: PullCord; ProductInformation: https://www.nationalbimlibrary.com/en-gb/vox-ignis-limited/vilx-cpp-assist-call-pull-cord-plate/?lo=en-GB; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_75_75_04_04; Uniclass2015Title: AssistanceCallPulCordUnits; Uniclass2015Version: Products v1.15; Version: 1; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Dimensions(Type) - Height: 2500 mm
Constraints(Type) - Default Elevation: 0 mm
Pset_DistributionFlowElementCommon - Reference: BC5083-121:Standard; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit; Manufacturer: mailto:info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Host: Level : Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0221672 m2; Volume: 0.000127718 m3
Identity Data - Mark: 391
Other - Category: Plumbing Fixtures; Family: BC5083-121: Standard; Family and Type: BC5083-121: Standard; Type: BC5083-121: Standard; Type Id: BC5083-121: Standard
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: DB3001, DB3001:DB3001:496063
In: Level 1
Type - PredefinedType: SHOWER
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_76:Shower heads; CodePerformance: WRAS; Color: Various; Constituents: n/a; Description: UltraThinRoundShowerHead; DurationUnit: year; ExpectedLife: n/a; Features: 88Nozzles_6&9LitreFlowRegulators; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel_.5/PowderCoated_.6/CeramicCoated; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3001; ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3001; Name: ShowerHeads_WRAS_DB3001_UltraThinRoundShowerHead_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 44 mm; NominalWidth: 250 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-round-shower-head/; ReplacementCost: n/a; Shape: Rectangular; Size: 250x44; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3001; Uniclass2015Code: Pr_40_20_87_76; Uniclass2015Title: Shower heads; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3001
Type - Pset_SanitaryTerminalTypeBath - Color: Various
Type - Pset_SanitaryTerminalTypeBidet - Color: Various
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: Various
Type - Pset_SanitaryTerminalTypeShower - Color: Various
Type - Pset_SanitaryTerminalTypeSink - Color: Various
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: Various
Pset_DistributionFlowElementCommon - Reference: DB3001:DB3001; sets with these values: 2
Pset_ElementShading - Color: Various
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3001; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerHeads_WRAS_DB3001_UltraThinRoundShowerHead_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 2250 mm; Host: Level : Level 1; Offset from Host: 2250 mm
Dimensions - Area: 0.0518063 m2; Volume: 0.000245526 m3
Identity Data - Mark: 377
Other - Family: DB3001: DB3001; Family and Type: DB3001: DB3001; Type: DB3001: DB3001; Type Id: DB3001: DB3001
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: DB3020, DB3020:DB3020:496067
In: Level 1
Type - PredefinedType: SHOWER
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_76:Shower heads; CodePerformance: WRAS; Color: BrushedSatin/MirrorPolished; Constituents: n/a; Description: HandHeldShowerHead; DurationUnit: year; ExpectedLife: n/a; Features: 6&9LitreFlowRegulators; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3020; ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3020; Name: ShowerHeads_WRAS_DB3020_HandHeldShowerHead_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 185 mm; NominalWidth: 23 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-hand-held-shower-head/; ReplacementCost: n/a; Size: 185x23; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3020; Uniclass2015Code: Pr_40_20_87_76; Uniclass2015Title: Shower heads; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3020
Type - Pset_SanitaryTerminalTypeBath - Color: BrushedSatin/MirrorPolished
Type - Pset_SanitaryTerminalTypeBidet - Color: BrushedSatin/MirrorPolished
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: BrushedSatin/MirrorPolished
Type - Pset_SanitaryTerminalTypeShower - Color: BrushedSatin/MirrorPolished
Type - Pset_SanitaryTerminalTypeSink - Color: BrushedSatin/MirrorPolished
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: BrushedSatin/MirrorPolished
Pset_DistributionFlowElementCommon - Reference: DB3020:DB3020; sets with these values: 2
Pset_ElementShading - Color: BrushedSatin/MirrorPolished
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3020; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerHeads_WRAS_DB3020_HandHeldShowerHead_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 1220 mm; Host: Level : Level 1; Offset from Host: 1220 mm
Dimensions - Area: 0.00832223 m2; Volume: 0.0000782395 m3
Identity Data - Mark: 381
Other - Family: DB3020: DB3020; Family and Type: DB3020: DB3020; Type: DB3020: DB3020; Type Id: DB3020: DB3020
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: DB3041, DB3041:DB3041:496066
In: Level 1
Type - PredefinedType: SHOWER
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Brushed Satin; Constituents: n/a; Description: Shower hose; DurationUnit: year; ExpectedLife: n/a; Features: "1/2""BSP_connection_SS316"; Finish: Brushed Satin; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3041; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3041_ShowerHose; Name: ShowerFittingsPackage_WRAS_DB3041_ShowerHose_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalLength: 1500 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-shower-hose/; ReplacementCost: n/a; Size: 1500 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3041; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3041
Type - Pset_SanitaryTerminalTypeBath - Color: Brushed Satin
Type - Pset_SanitaryTerminalTypeBidet - Color: Brushed Satin
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: Brushed Satin
Type - Pset_SanitaryTerminalTypeShower - Color: Brushed Satin
Type - Pset_SanitaryTerminalTypeSink - Color: Brushed Satin
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: Brushed Satin
Pset_DistributionFlowElementCommon - Reference: DB3041:DB3041; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3041_ShowerHose; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_DB3041_ShowerHose_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 1220 mm; Host: Level : Level 1; Offset from Host: 1220 mm
Dimensions - Area: 0.0173889 m2; Volume: 0.000129094 m3
Identity Data - Mark: 380
Other - Family: DB3041: DB3041; Family and Type: DB3041: DB3041; Type: DB3041: DB3041; Type Id: DB3041: DB3041
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: DB3061.350, DB3061:DB3061.350:496064
In: Level 1
Type - PredefinedType: USERDEFINED
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 350 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: BrushedSatin/MirrorPolished; Constituents: n/a; Description: Shower arm; DurationUnit: year; ExpectedLife: n/a; Features: Available in 4 lengths; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass; ModelNumber: DB3061.300/DB3061.350/DB3061.400/DB3061.450; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3061; Name: ShowerFittingsPackage_WRAS_DB3061_ShowerArm_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 0; NominalLength: 215 mm; NominalWidth: 0; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-shower-arm-2/; ReplacementCost: n/a; Shape: n/a; Size: 215 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3061.350; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: 2; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3061
Type - Pset_SanitaryTerminalTypeBath - Color: BrushedSatin/MirrorPolished
Type - Pset_SanitaryTerminalTypeBidet - Color: BrushedSatin/MirrorPolished
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: BrushedSatin/MirrorPolished
Type - Pset_SanitaryTerminalTypeShower - Color: BrushedSatin/MirrorPolished
Type - Pset_SanitaryTerminalTypeSink - Color: BrushedSatin/MirrorPolished
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: BrushedSatin/MirrorPolished
Pset_DistributionFlowElementCommon - Reference: DB3061:DB3061.350; sets with these values: 2
Pset_ElementShading - Color: BrushedSatin/MirrorPolished
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3061; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_DB3061_ShowerArm_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 2350 mm; Host: Level : Level 1; Offset from Host: 2350 mm
Dimensions - Area: 0.0165068 m2; Volume: 0.000155136 m3
Identity Data - Mark: 378
Other - Family: DB3061: DB3061.350; Family and Type: DB3061: DB3061.350; Type: DB3061: DB3061.350; Type Id: DB3061: DB3061.350
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: DB3090.450, DB3090.450:DB3090.450:496068
In: Level 1
Type - PredefinedType: SHOWER
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Brushed Satin; Constituents: n/a; Description: Shower slider rail and holder; DurationUnit: year; ExpectedLife: n/a; Finish: Brushed Satin; Grade: CZ121; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass; ModelNumber: DB3090.450; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3090.450_ShowerSliderRailAndHolder; Name: ShowerFittingsPackage_WRAS_DB3090.450_ShowerSliderRailAndHolder_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 79 mm; NominalLength: 450mm; NominalWidth: 18 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-450mm-shower-slider-rail-and-holder/; ReplacementCost: n/a; Size: 18x450x79 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3090.450; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3090.450
Type - Pset_SanitaryTerminalTypeBath - Color: Brushed Satin
Type - Pset_SanitaryTerminalTypeBidet - Color: Brushed Satin
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: Brushed Satin
Type - Pset_SanitaryTerminalTypeShower - Color: Brushed Satin
Type - Pset_SanitaryTerminalTypeSink - Color: Brushed Satin
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: Brushed Satin
Pset_DistributionFlowElementCommon - Reference: DB3090.450:DB3090.450; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3090.450_ShowerSliderRailAndHolder; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_DB3090.450_ShowerSliderRailAndHolder_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 1025 mm; Host: Level : Level 1; Offset from Host: 1025 mm
Dimensions - Area: 0.0274225 m2; Volume: 0.000227501 m3
Identity Data - Mark: 382
Other - Family: DB3090.450: DB3090.450; Family and Type: DB3090.450: DB3090.450; Type: DB3090.450: DB3090.450; Type Id: DB3090.450: DB3090.450
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: DP600500:DP600500, DP600500:DP600500:496075
In: Level 1
Other(Type) - Category: Plumbing Fixtures; Family Name: DP600500
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182; Color: Brushed Satin; Constituents: n/a; Description: 600mm Long 32mm Grab Rail 75mm Rosettes; DurationUnit: year; ExpectedLife: n/a; Features: 74mm wall clearance; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DP600600; ModelReference: DolphinSolutionsLimited_32mmGrabRail; Name: SupportRails_32mmGrabRail_DP600600_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 106 mm; NominalLength: 600 mm; NominalWidth: 32 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-grab-rail/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 600 x 32 x 106 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DP600500; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Dimensions(Type) - Depth: 106 mm; Width: 500 mm
Constraints(Type) - Default Elevation: 0 mm
Pset_DistributionFlowElementCommon - Reference: DP600500:DP600500; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail; Manufacturer: mailto:info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: SupportRails_32mmGrabRail_DP600600_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 665 mm; Host: Level : Level 1; Offset from Host: 665 mm
Dimensions - Area: 0.0427258 m2; Volume: 0.000611089 m3
Identity Data - Mark: 389
Other - Category: Plumbing Fixtures; Family: DP600500: DP600500; Family and Type: DP600500: DP600500; Type: DP600500: DP600500; Type Id: DP600500: DP600500
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: DP600600:DP600600 (3)
In: Level 1
Other(Type) - Category: Plumbing Fixtures; Family Name: DP600600
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182; Color: Brushed Satin; Constituents: n/a; Description: 600mm Long 32mm Grab Rail 75mm Rosettes; DurationUnit: year; ExpectedLife: n/a; Features: 74mm wall clearance; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DP600600; ModelReference: DolphinSolutionsLimited_32mmGrabRail; Name: SupportRails_32mmGrabRail_DP600600_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 106 mm; NominalLength: 600 mm; NominalWidth: 32 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-grab-rail/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 600 x 32 x 106 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DP600600; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Dimensions(Type) - Depth: 106 mm; Width: 600 mm
Pset_DistributionFlowElementCommon - Reference: DP600600:DP600600; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail; Manufacturer: mailto:info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: SupportRails_32mmGrabRail_DP600600_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1
Dimensions - Area: 0.0477523 m2; Volume: 0.000691514 m3
Other - Category: Plumbing Fixtures; Family: DP600600: DP600600; Family and Type: DP600600: DP600600; Type: DP600600: DP600600; Type Id: DP600600: DP600600
Phasing - Phase Created: Phase 1
Constraints(Type) - Default Elevation: 1219.2 mm
Name (DP600600:DP600600:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
496074 | 665 | 388
496076 | 665 | 390
496081 | 1100 | 395

# IfcFlowTerminal: DP670300:DP670300 (2)
In: Level 1
Pset_DistributionFlowElementCommon - Reference: DP670300:DP670300; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail; Manufacturer: mailto:info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: SupportRails_800mmFoldHingedDown32mmGrabRail_DP670300_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 567.285 mm; Host: Level : Level 1; Offset from Host: 567.285 mm
Dimensions - Area: 0.121409 m2; Volume: 0.00162606 m3
Other - Category: Plumbing Fixtures; Family: DP670300: DP670300; Family and Type: DP670300: DP670300; Type: DP670300: DP670300; Type Id: DP670300: DP670300
Phasing - Phase Created: Phase 1
Other(Type) - Category: Plumbing Fixtures; Family Name: DP670300
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182_DocM_BS8300; Color: Brushed Satin; Constituents: n/a; Description: 800mm Hinged Fold Down Grab Rail; DurationUnit: year; ExpectedLife: n/a; Features: 800mm Fold Down; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DP670300; ModelReference: DolphinSolutionsLimited_32mmGrabRail; Name: SupportRails_800mmFoldHingedDown32mmGrabRail_DP670300_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 250 mm; NominalLength: 800 mm; NominalWidth: 90 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-support-rail-hinged/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 800 x 90 x 250 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DP670300; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Dimensions(Type) - Depth: 850 mm; Height: 250 mm; Width: 90 mm
Constraints(Type) - Default Elevation: 0 mm
Name (DP670300:DP670300:...) | Mark
496073 | 387
496079 | 393

# IfcFlowTerminal: DP7102:DP7102 (2)
In: Level 1
Pset_DistributionFlowElementCommon - Reference: DP7102:DP7102; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin or PolishedDP7102PSS
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ClothesHooks; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: Clothes hooks_DP7102_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1
Dimensions - Area: 0.00317703 m2; Volume: 0.0000150863 m3
Other - Category: Plumbing Fixtures; Family: DP7102: DP7102; Family and Type: DP7102: DP7102; Type: DP7102: DP7102; Type Id: DP7102: DP7102
Phasing - Phase Created: Phase 1
Other(Type) - Category: Plumbing Fixtures; Family Name: DP7102
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_15:Clothes hooks; CodePerformance: n/a; Color: Brushed Satin or PolishedDP7102PSS; Constituents: n/a; Description: Clothes hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin or PolishedDP7103PSS; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: www.dolphinsolutions.co.uk; Material: StainlessSteel; ModelNumber: DP7102; ModelReference: DolphinSolutionsLimited_ClothesHooks; Name: Clothes hooks_DP7102_DolphinSolutionsLimited; NBSDescription: Clothes hooks; NBSReference: 45-35-72/322; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 45; NominalWidth: 47; ObjectClassification1: OmniClass; ObjectClassification2: 23.40.20.21.31; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-robe-hook-dp7102/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 47 x 45 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DP7102; Uniclass2015Code: Pr_40_30_78_15; Uniclass2015Title: Clothes hooks; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Constraints(Type) - Default Elevation: 0 mm
Dimensions(Type) - Depth: 36 mm; Height: 380 mm; Width: 47 mm
Name (DP7102:DP7102:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
496072 | 1400 | 386
496080 | 1050 | 394

# IfcFlowTerminal: Family1, DB3073:Family1:496065
In: Level 1
Type - PredefinedType: SHOWER
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Various; Constituents: n/a; Description: Shower wall outlet and holder; DurationUnit: year; ExpectedLife: n/a; Features: "1/2""BSP_connection"; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel_.5/PowderCoated_.6/CeramicCoated; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3073; ModelReference: ShowerFittingsPackages_DolphinSolutionsLimited_WRAS_DB3073; Name: ShowerFittingsPackages_WRAS_DB3073_ShowerWallOutletAndHolder_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 31 mm; NominalWidth: 68 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-shower-wall-outlet-and-holder-2/; ReplacementCost: n/a; Size: 31x68 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Family1; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3073
Type - Pset_SanitaryTerminalTypeBath - Color: Various
Type - Pset_SanitaryTerminalTypeBidet - Color: Various
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: Various
Type - Pset_SanitaryTerminalTypeShower - Color: Various
Type - Pset_SanitaryTerminalTypeSink - Color: Various
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: Various
Pset_DistributionFlowElementCommon - Reference: DB3073:Family1; sets with these values: 2
Pset_ElementShading - Color: Various
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackages_DolphinSolutionsLimited_WRAS_DB3073; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerFittingsPackages_WRAS_DB3073_ShowerWallOutletAndHolder_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 920 mm; Host: Level : Level 1; Offset from Host: 920 mm
Dimensions - Area: 0.00716927 m2; Volume: 0.0000498867 m3
Identity Data - Mark: 379
Other - Family: DB3073: Family1; Family and Type: DB3073: Family1; Type: DB3073: Family1; Type Id: DB3073: Family1
Phasing - Phase Created: Phase 1

# IfcFurnishingElement: BC5083-13 (24)
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; CodePerformance: n/a; Color: Chrome; Constituents: n/a; Description: Shower curtain hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Chrome Plated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass Chrome Plated; ModelNumber: BC5083-13; ModelReference: ShowerCurtainHooks_DolphinSolutionsLimited_BC5083-13; Name: ShowerCurtainHooks_BC5083-13_DolphinSolutionsLimited; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-curtain-hooks-brass-chrome-plated/; ReplacementCost: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-13; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-13
Type - Pset_FurnitureTypeCommon - Description: Shower curtain hooks
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainHooks_DolphinSolutionsLimited_BC5083-13; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerCurtainHooks_BC5083-13_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-13:BC5083-13
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 2100 mm; Host: Level : Level 1; Offset from Host: 2100 mm
Dimensions - Area: 0.0013773 m2; Volume: 0.00000205534 m3
Other - Family: BC5083-13: BC5083-13; Family and Type: BC5083-13: BC5083-13; Type: BC5083-13: BC5083-13; Type Id: BC5083-13: BC5083-13
Phasing - Phase Created: Phase 1
Name (BC5083-13:BC5083-13:...) | Mark
496265 | 577
496266 | 578
496267 | 579
496268 | 580
496269 | 581
496270 | 582
496271 | 583
496272 | 584
496273 | 585
496274 | 586
496275 | 587
496276 | 588
496278 | 590
496279 | 591
496280 | 592
496281 | 593
496282 | 594
496283 | 595
496284 | 596
496285 | 597
496286 | 598
496287 | 599
496288 | 600
496289 | 601

# IfcFurnishingElement: BC5083-33, BC5083-33:BC5083-33:496071
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_06_83:Shower seats; CodePerformance: BSEN12182; Color: Pale grey_white metal; Constituents: n/a; Description: Shower seat; DurationUnit: year; ExpectedLife: n/a; Finish: n/a; IfcExportAs: IfcFurnitureType; IfcExportType: CHAIR; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: DiecastAluminium_VacuumMouldedPolyethylene; ModelNumber: BC5083-33; ModelReference: ShowerSeats_DolphinSolutionsLimited_BC5083-33_ShowerSeat; Name: ShowerSeats_BC5083-33_ShowerSeat_DolphinSolutionsLimited; NBSDescription: Shower seats; NBSReference: 45-35-72/352; NominalHeight: 220 mm; NominalLength: 650 mm; NominalWidth: 450 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.11.17; OmniClass Number: 23.45.05.14.11.17; OmniClass Title: Shower/Bath Seats; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-seat/; ReplacementCost: n/a; Shape: Rectangular; Size: 450x650x220; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-33; Uniclass2015Code: Pr_40_20_06_83; Uniclass2015Title: Shower seats; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-33
Type - Pset_FurnitureTypeCommon - Description: Shower seat
Pset_ElementShading - Color: Pale grey_white metal
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerSeats_DolphinSolutionsLimited_BC5083-33_ShowerSeat; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerSeats_BC5083-33_ShowerSeat_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-33:BC5083-33
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 485 mm; Host: Level : Level 1; Offset from Host: 485 mm
Dimensions - Area: 0.372725 m2; Volume: 0.0101955 m3
Identity Data - Mark: 385
Other - Family: BC5083-33: BC5083-33; Family and Type: BC5083-33: BC5083-33; Type: BC5083-33: BC5083-33; Type Id: BC5083-33: BC5083-33
Phasing - Phase Created: Phase 1

# IfcFurnishingElement: BC5083-34, BC5083-34:BC5083-34:496070
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_06_83:Shower seats; Color: Pale grey_white metal; Constituents: n/a; Description: Shower seat back rest; DurationUnit: year; ExpectedLife: n/a; Finish: n/a; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: DiecastAluminium_VacuumMouldedPolyethylene; ModelNumber: BC5083-34; ModelReference: ShowerSeat_DolphinSolutionsLimited_BC5083-34_ShowerSeatBackRest; Name: ShowerSeat_BC5083-34_ShowerSeatBackRest_DolphinSolutionsLimited; NBSDescription: Shower seats; NBSReference: 45-35-72/352; NominalHeight: 189 mm; NominalLength: 160 mm; NominalWidth: 450 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.11.17; OmniClass Number: 23.45.05.14.11.17; OmniClass Title: Shower/Bath Seats; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-back-rest/; ReplacementCost: n/a; Shape: Rectangular; Size: 450x160x189; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-34; Uniclass2015Code: Pr_40_20_06_83; Uniclass2015Title: Shower seats; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-34
Type - Pset_FurnitureTypeCommon - Description: Shower seat back rest
Pset_ElementShading - Color: Pale grey_white metal
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerSeat_DolphinSolutionsLimited_BC5083-34_ShowerSeatBackRest; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerSeat_BC5083-34_ShowerSeatBackRest_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-34:BC5083-34
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 820 mm; Host: Level : Level 1; Offset from Host: 820 mm
Dimensions - Area: 0.152202 m2; Volume: 0.00723579 m3
Identity Data - Mark: 384
Other - Family: BC5083-34: BC5083-34; Family and Type: BC5083-34: BC5083-34; Type: BC5083-34: BC5083-34; Type Id: BC5083-34: BC5083-34
Phasing - Phase Created: Phase 1

# IfcFurnishingElement: DP680300, DP680300:DP680300:496069
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 1200 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_20_77:Shower curtain rails; CodePerformance: n/a; Color: Brushed Satin; Constituents: n/a; Description: Shower curtain rails; DurationUnit: year; ExpectedLife: n/a; Features: Concealed fixings; Finish: Brushed Satin; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DP680300; ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_DP680300; Name: ShowerCurtainRails_DP680300_ShowerCurtainRail_DolphinSolutionsLimited; NBSDescription: Shower curtain rails; NBSReference: 45-35-70/334; NominalLength: 1200 mm; NominalWidth: 1200 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; ReplacementCost: n/a; Size: 1200x1200; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DP680300; Uniclass2015Code: Pr_40_30_20_77; Uniclass2015Title: Shower curtain rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DP680300
Type - Pset_FurnitureTypeCommon - Description: Shower curtain rails
Pset_ElementShading - Color: Brushed Satin
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_DP680300; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerCurtainRails_DP680300_ShowerCurtainRail_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: DP680300:DP680300
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 2025 mm; Host: Level : Level 1; Offset from Host: 2025 mm
Dimensions - Area: 0.131485 m2; Volume: 0.00201028 m3
Identity Data - Mark: 383
Other - Family: DP680300: DP680300; Family and Type: DP680300: DP680300; Type: DP680300: DP680300; Type Id: DP680300: DP680300
Phasing - Phase Created: Phase 1

# IfcFurnishingElement: Standard (2)
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; CodePerformance: n/a; Color: White; Constituents: n/a; Description: Shower curtain; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: 4oz Weighted White Polyester; ModelNumber: BC5083-14L; ModelReference: ShowerCurtain_DolphinSolutionsLimited_BC5083-14L; Name: ShowerCurtain_BC5083-14L_DolphinSolutionsLimited; NominalHeight: 1830 mm; NominalLength: 2100 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-curtain/; ReplacementCost: n/a; Size: 2100x1830; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-14L
Type - Pset_FurnitureTypeCommon - Description: Shower curtain
Pset_ElementShading - Color: White
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtain_DolphinSolutionsLimited_BC5083-14L; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerCurtain_BC5083-14L_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-14L:Standard
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 200 mm; Host: Level : Level 1; Offset from Host: 200 mm
Dimensions - Area: 1.91829 m2; Volume: 0.00191533 m3
Other - Family: BC5083-14L: Standard; Family and Type: BC5083-14L: Standard; Type: BC5083-14L: Standard; Type Id: BC5083-14L: Standard
Phasing - Phase Created: Phase 1
Name (BC5083-14L:Standard:...) | Mark
496264 | 576
496277 | 589
